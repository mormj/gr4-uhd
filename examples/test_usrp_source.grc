options:
  parameters:
    author: josh
    generate_options: pyqtgraph
    id: test_usrp_source
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: pyqtgraph_pg_time_sink_0
  id: pyqtgraph_pg_time_sink
  parameters:
    T: complex
    dock_position: top
    dock_relative_to: ''
    impl: numpy
    nports: '1'
    samp_rate: samp_rate
    showports: 'False'
    size: '10240'
    title: None
    ylabel: Amplitude
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '2450000000'
    gain0: '30'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', pyqtgraph_pg_time_sink_0, '0']

metadata:
  file_format: 1
